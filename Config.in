## package/myfw-ctl/Config.in
```kconfig
config BR2_PACKAGE_MYFW_CTL
        bool "myfw-ctl"
        help
          User-space Generic Netlink to control myfw firewall.
```
